SUMMARY = "A set of dashboard nodes for Node-RED"

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "Apache-2.0 & MIT & ISC"
LIC_FILES_CHKSUM = "file://LICENSE;md5=088ce976a5d78ef059391f1ca042eb3d"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
